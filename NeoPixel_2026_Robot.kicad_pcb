# Repository H-goemon/NeoPixcel_20206_Robot

## KiCad design NeoPixel_2026_Robot.kicad_pcb

Parts:
A1: Arduino_Nano_v3.x; Arduino_Nano
H1, H2, H3, H4: MountingHole; MountingHole_3.5mm_Pad
J1: Pixcel1; JST_XA_B03B-XASK-1_1x03_P2.50mm_Vertical
J2: Pixcel2; JST_XA_B03B-XASK-1_1x03_P2.50mm_Vertical
J3: Pixcel3; JST_XA_B03B-XASK-1_1x03_P2.50mm_Vertical
J4: Pixcel4; JST_XA_B03B-XASK-1_1x03_P2.50mm_Vertical
J5: INPUT; JST_XA_S05B-XASK-1_1x05_P2.50mm_Horizontal
J6: EM-IN1; JST_XA_B02B-XASK-1_1x02_P2.50mm_Vertical
J7: EM-IN2; JST_XA_B02B-XASK-1_1x02_P2.50mm_Vertical
J8: EM-IN3; JST_XA_B02B-XASK-1_1x02_P2.50mm_Vertical
J9: EM-IN4; JST_XA_B02B-XASK-1_1x02_P2.50mm_Vertical
J10: XT30; AMASS_XT30PW-M_1x02_P2.50mm_Horizontal
J11: Type-C; PowerOnlyUSB_C
JP1: EM-JP1; PinHeader_1x02_P2.54mm_Vertical
JP2: EM-JP2; PinHeader_1x02_P2.54mm_Vertical
JP3: EM-JP3; PinHeader_1x02_P2.54mm_Vertical
JP4: EM-JP4; PinHeader_1x02_P2.54mm_Vertical
R1, R3, R5, R7: R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2, R4, R6, R8: R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
U1, U2, U3, U4: TLP291; SOIC-4_4.55x2.6mm_P1.27mm

Connections:
+3.3V: A1.17 (3V3)
+5V: A1.27 (+5V), J1.1, J2.1, J3.1, J4.1, J10.1, J11.1, R2.1, R4.1, R6.1, R8.1
/EM-sig: A1.13 (D10), J6.1, JP1.1 (A)
/NRST: A1.3 (~RESET), A1.28 (~RESET)
/Pixcel1: A1.9 (D6), J1.2
/Pixcel2: A1.10 (D7), J2.2
/Pixcel3: A1.11 (D8), J3.2
/Pixcel4: A1.12 (D9), J4.2
/Sig1_IN: J5.1, R1.1
/Sig1_OUT: A1.5 (D2), R2.2, U1.4
/Sig2_IN: J5.2, R3.1
/Sig2_OUT: A1.6 (D3), R4.2, U2.4
/Sig3_IN: J5.3, R5.1
/Sig3_OUT: A1.7 (D4), R6.2, U3.4
/Sig4_IN: J5.4, R7.1
/Sig4_OUT: A1.8 (D5), R8.2, U4.4
GND: J5.5, U1.2, U2.2, U3.2, U4.2
GNDPWR: A1.4 (GND), A1.29 (GND), J1.3, J2.3, J3.3, J4.3, J9.2, J10.2, J11.2, JP4.2 (B), U1.3, U2.3, U3.3, U4.3
unnamed: J6.2, J7.1, JP1.2 (B), JP2.1 (A)
unnamed: J7.2, J8.1, JP2.2 (B), JP3.1 (A)
unnamed: J8.2, J9.1, JP3.2 (B), JP4.1 (A)
unnamed: R1.2, U1.1
unnamed: R3.2, U2.1
unnamed: R5.2, U3.1
unnamed: R7.2, U4.1

Notes on the sheet:
5pin_INPUT
Isolation
OUTPUT
Emergency_INPUT
Power_INPUT
INPUT
↘部室にあるTHTはR2の規格
MCU(Arduino_Nano)

Board: 2 copper layers, 32 parts (0 on the bottom side), 24 nets, no tracks yet.
